# Keil uVision project LPC_2141.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2141 NXP
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC_2141 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source Group 1
    ./: Startup.s
  group Source
    ./Source/: HARDWARE .c GPIO.c UART.c ADC.c PWM.c TIMER.c EINT.c SPI.c main.c
  group Include
    ./Include/: HARDWARE.h GPIO.h UART.h ADC.h PWM.h TIMER.h EINT.h SPI.h
  group readme
    ./readme/: readme.txt
